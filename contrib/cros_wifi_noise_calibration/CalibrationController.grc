options:
  parameters:
    generate_options: qt_gui
    id: CalibrationController
    output_language: python
    qt_qss_theme: ./plain2.qss
    title: New Calibration Controller
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: vals.get_center_freq(frequency)
  states: {}
- name: display
  id: variable_qtgui_label
  parameters:
    gui_hint: 0,0,2,2
    label: 'Output Power: '
    type: string
    value: '"{0} dBm".format(measured_power/10)'
  states: {}
- name: frequency
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 2,1,1,1
    label: Frequency (MHz)
    labels: '["2442","5150","5350","5945","6525","7125"]'
    num_opts: '0'
    options: '[0,1,2,3,4,5]'
    orient: Qt.QHBoxLayout
    type: raw
    value: '0'
    widget: radio_buttons
  states: {}
- name: if_gain
  id: variable
  parameters:
    value: vals.get_IF_gain(noise_source,frequency)
  states: {}
- name: measured_power
  id: variable
  parameters:
    value: vals.get_RF_Pout_x10(noise_source,frequency)
  states: {}
- name: noise_source
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 2,0,1,1
    label: Signal Source
    label0: Nothing
    label1: AWGN
    label2: 1MHZ Cosine
    label3: 5MHZ Cosine
    labels: ''
    num_opts: '4'
    option0: '0'
    option1: '1'
    option2: '2'
    option3: '3'
    options: ''
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: rf_amplifier
  id: variable
  parameters:
    value: vals.get_RF_gain(noise_source,frequency)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: vals.get_samp_rate(noise_source,frequency)
  states: {}
- name: analog_const_source_x_1
  id: analog_const_source_x
  parameters:
    const: '0'
    type: complex
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 1e6
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 5e6
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: noise_source
    num_inputs: '4'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: network_tcp_sink_0
  id: network_tcp_sink
  parameters:
    addr: 127.0.0.1
    mode: '1'
    port: '1234'
    type: complex
  states: {}
- name: soapy_hackrf_sink_0
  id: soapy_hackrf_sink
  parameters:
    amp: True if rf_amplifier == 14 else 0
    center_freq: center_freq
    samp_rate: samp_rate
    type: fc32
    vga: if_gain
  states: {}
- name: vals
  id: epy_module
  parameters:
    source_code: |
      # this module will be imported in the into your flowgraph
      from enum import Enum

      class Noise(Enum):
      	NOTHING=0	# Carrier OFF
      	AWGN=1		# AWGN
      	COS1=2		# +/-1MHz Modulated Sine waves
      	COS5=3		# +/-5MHz Modulated Sine waves
      	
      	def __int__(self):
      		return self.value

      center_freq_list_MHz = [2442.0,5150.0,5350.0,5945.0,6525.0,7125.0]
      samp_rate_matrix_MHz = [1,15,2,10]
      IF_gain_matrix = \
      		[[0,	0,	0,	0,	0,	0],	# Carrier OFF
      		[47,	47,	47,	47,	47,	47],	# AWGN
      		[45,	43,	44,	41,	42,	43],	# +/-1MHz Modulated Sine waves
      		[32,	31,	34,	38,	42,	43]]	# +/-5MHz Modulated Sine waves
      		#2442.0	5150.0	5350.0	5945.0	6525.0	7125.0	# Frequency
      RF_gain_matrix = \
      		[[0,	0,	0,	0,	0,	0],	# Carrier OFF
      		[14,	14,	14,	14,	14,	14],	# AWGN
      		[0,	14,	14,	14,	14,	14],	# +/-1MHz Modulated Sine waves
      		[14,	14,	14,	14,	14,	14]]	# +/-5MHz Modulated Sine waves
      		#2442.0	5150.0	5350.0	5945.0	6525.0	7125.0	# Frequency
      RF_Pout_matrix_dBm_x10 = \
      		[[-1740,-1740,	-1740,	-1740,	-1740,	-1740],	# Carrier OFF
      		[126,	-129,	-127,	-142,	-267,	-289],	# AWGN
      		[24,	-135,	-125,	-165,	-282,	-296],	# +/-1MHz Modulated Sine waves
      		[12,	-266,	-237,	-216,	-304,	-317]]	# +/-5MHz Modulated Sine waves
      		#2442.0	5150.0	5350.0	5945.0	6525.0	7125.0	# Frequency
      		
      def get_IF_gain(noise_type, frequency_index):
      	return IF_gain_matrix[int(noise_type)][frequency_index]

      def get_RF_gain(noise_type, frequency_index):
      	return RF_gain_matrix[int(noise_type)][frequency_index]
      	
      def get_RF_Pout_x10(noise_type, frequency_index):
      	return RF_Pout_matrix_dBm_x10[int(noise_type)][frequency_index]
      	
      def get_samp_rate(noise_type, frequency_index):
      	return samp_rate_matrix_MHz[int(noise_type)]*1e6

      def get_center_freq(center_freq_index):
      	return center_freq_list_MHz[center_freq_index]*1e6
  states: {}
- name: xmlrpc_client_0
  id: xmlrpc_client
  parameters:
    addr: localhost
    callback: set_samp_rate
    port: '8080'
    variable: samp_rate
  states: {}
- name: xmlrpc_client_0_0
  id: xmlrpc_client
  parameters:
    addr: localhost
    callback: set_center_freq
    port: '8080'
    variable: center_freq
  states: {}

connections:
- [analog_const_source_x_1, '0', blocks_selector_0, '0']
- [analog_noise_source_x_0, '0', blocks_selector_0, '1']
- [analog_sig_source_x_0, '0', blocks_selector_0, '2']
- [analog_sig_source_x_1, '0', blocks_selector_0, '3']
- [blocks_selector_0, '0', network_tcp_sink_0, '0']
- [blocks_selector_0, '0', soapy_hackrf_sink_0, '0']

metadata:
  file_format: 1
