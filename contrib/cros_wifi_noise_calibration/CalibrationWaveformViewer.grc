options:
  parameters:
    generate_options: qt_gui
    id: CalibrationViewer
    output_language: python
    title: Calibration Waveform Viewer
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: network_tcp_source_0
  id: network_tcp_source
  parameters:
    addr: 127.0.0.1
    port: '1234'
    server: 'True'
    type: complex
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate*2
    fc: center_freq
    fftsize: '1024'
    plotconst: 'False'
    plottime: 'False'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '2'
    type: ccc
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: localhost
    port: '8080'
  states: {}

connections:
- [blocks_throttle_0, '0', rational_resampler_xxx_0, '0']
- [network_tcp_source_0, '0', blocks_throttle_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
